# Keil uVision project Design115_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Design115_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h SW2.c SW2.h SW2_aliases.h LCD.c LCD.h LCD_PM.c USBUART.c USBUART.h USBUART_audio.c USBUART_audio.h USBUART_boot.c USBUART_cdc.c USBUART_cdc.h USBUART_cls.c USBUART_descr.c USBUART_drv.c USBUART_episr.c USBUART_hid.c USBUART_hid.h USBUART_pm.c USBUART_std.c USBUART_vnd.c USBUART_cdc.inf USBUART_midi.c USBUART_midi.h USBUART_pvt.h SW3.c SW3.h SW3_aliases.h LED4.c LED4.h LED4_aliases.h LED3.c LED3.h LED3_aliases.h int_uartQueue.c int_uartQueue.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h USBUART_Dm.c USBUART_Dm.h USBUART_Dm_aliases.h USBUART_Dp.c USBUART_Dp.h USBUART_Dp_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Clock_4kHz.c Clock_4kHz.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Design115_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
